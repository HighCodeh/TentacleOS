// Copyright (c) 2025 HIGH CODE LLC
// SPDX-License-Identifier: GPL-3.0-or-later
//
// TentacleOS is free software: you can redistribute it and/or modify
// it under the terms of the GNU General Public License as published by
// the Free Software Foundation, either version 3 of the License, or
// (at your option) any later version.
//
// TentacleOS is distributed in the hope that it will be useful,
// but WITHOUT ANY WARRANTY; without even the implied warranty of
// MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE. See the
// GNU General Public License for more details.
//
// You should have received a copy of the GNU General Public License
// along with TentacleOS. If not, see <https://www.gnu.org/licenses/>.

#include "mac_vendor.h"

#include <string.h>

#define LOCALLY_ADMINISTERED_BIT 0x02

typedef struct {
  uint8_t oui[3];
#ifndef MAC_VENDOR_ESPRESSIF_ONLY
  const char *name;
#endif
} mac_vendor_oui_t;

// The AP heuristic needs only Espressif; keep one prefix list for both builds.
#ifdef MAC_VENDOR_ESPRESSIF_ONLY
#define ESPRESSIF_OUI(a, b, c) \
  {                            \
    { a, b, c }                \
  }
#else
#define ESPRESSIF_OUI(a, b, c) {{a, b, c}, "Espressif"}
#endif

static const mac_vendor_oui_t COMMON_VENDORS[] = {
#ifndef MAC_VENDOR_ESPRESSIF_ONLY
    {{0x00, 0x1A, 0x11}, "Google"},       {{0x3C, 0x5A, 0xB4}, "Google"},
    {{0x54, 0x60, 0x09}, "Google"},

    {{0x00, 0x17, 0x88}, "Philips"},

    {{0x00, 0x1D, 0xA5}, "Cisco"},        {{0x00, 0x24, 0x14}, "Cisco"},

    {{0x00, 0x0C, 0x29}, "VMware"},       {{0x00, 0x50, 0x56}, "VMware"},

    {{0x00, 0x1A, 0x2B}, "Ayecom"},

    {{0x00, 0x1E, 0x52}, "Atheros"},

    {{0xDC, 0xA6, 0x32}, "Raspberry Pi"}, {{0xB8, 0x27, 0xEB}, "Raspberry Pi"},
    {{0xE4, 0x5F, 0x01}, "Raspberry Pi"},

#endif
    ESPRESSIF_OUI(0x10, 0xBD, 0xA3),      ESPRESSIF_OUI(0x18, 0xFE, 0x34),
    ESPRESSIF_OUI(0x24, 0x0A, 0xC4),      ESPRESSIF_OUI(0x24, 0x6F, 0x28),
    ESPRESSIF_OUI(0x24, 0x62, 0xAB),      ESPRESSIF_OUI(0x30, 0xAE, 0xA4),
    ESPRESSIF_OUI(0x3C, 0x71, 0xBF),      ESPRESSIF_OUI(0x48, 0x3F, 0xDA),
    ESPRESSIF_OUI(0x48, 0x55, 0x19),      ESPRESSIF_OUI(0x54, 0x43, 0xB2),
    ESPRESSIF_OUI(0x5C, 0xCF, 0x7F),      ESPRESSIF_OUI(0x60, 0x01, 0x94),
    ESPRESSIF_OUI(0x60, 0x55, 0xF9),      ESPRESSIF_OUI(0x68, 0xC6, 0x3A),
    ESPRESSIF_OUI(0x70, 0x03, 0x9F),      ESPRESSIF_OUI(0x7C, 0x9E, 0xBD),
    ESPRESSIF_OUI(0x7C, 0xDF, 0xA1),      ESPRESSIF_OUI(0x80, 0x7D, 0x3A),
    ESPRESSIF_OUI(0x84, 0x0D, 0x8E),      ESPRESSIF_OUI(0x84, 0xCC, 0xA8),
    ESPRESSIF_OUI(0x8C, 0xAA, 0xB5),      ESPRESSIF_OUI(0x90, 0x97, 0xD5),
    ESPRESSIF_OUI(0x94, 0xB9, 0x7E),      ESPRESSIF_OUI(0xA0, 0x20, 0xA6),
    ESPRESSIF_OUI(0xA0, 0xB7, 0x65),      ESPRESSIF_OUI(0xA4, 0x7B, 0x9D),
    ESPRESSIF_OUI(0xA4, 0xCF, 0x12),      ESPRESSIF_OUI(0xAC, 0x67, 0xB2),
    ESPRESSIF_OUI(0xAC, 0xD0, 0x74),      ESPRESSIF_OUI(0xB0, 0xA7, 0x32),
    ESPRESSIF_OUI(0xB4, 0xE6, 0x2D),      ESPRESSIF_OUI(0xB8, 0xF0, 0x09),
    ESPRESSIF_OUI(0xBC, 0xDD, 0xC2),      ESPRESSIF_OUI(0xC4, 0x4F, 0x33),
    ESPRESSIF_OUI(0xC4, 0xDD, 0x57),      ESPRESSIF_OUI(0xC8, 0xF0, 0x9E),
    ESPRESSIF_OUI(0xCC, 0x50, 0xE3),      ESPRESSIF_OUI(0xD4, 0xD4, 0xDA),
    ESPRESSIF_OUI(0xD4, 0xF9, 0x8D),      ESPRESSIF_OUI(0xD8, 0xA0, 0x1D),
    ESPRESSIF_OUI(0xDC, 0x4F, 0x22),      ESPRESSIF_OUI(0xE0, 0x5A, 0x1B),
    ESPRESSIF_OUI(0xE8, 0x68, 0xE7),      ESPRESSIF_OUI(0xE8, 0x9F, 0x6D),
    ESPRESSIF_OUI(0xE8, 0xDB, 0x84),      ESPRESSIF_OUI(0xEC, 0x94, 0xCB),
    ESPRESSIF_OUI(0xEC, 0xDA, 0x3B),      ESPRESSIF_OUI(0xF0, 0x08, 0xD1),
    ESPRESSIF_OUI(0xF4, 0x12, 0xFA),

#ifndef MAC_VENDOR_ESPRESSIF_ONLY
    {{0x00, 0x17, 0xF2}, "Apple"},        {{0x00, 0x19, 0xE3}, "Apple"},
    {{0x00, 0x1B, 0x63}, "Apple"},        {{0x00, 0x1C, 0xB3}, "Apple"},
    {{0x00, 0x1D, 0x4F}, "Apple"},        {{0x00, 0x1E, 0x52}, "Apple"},
    {{0x00, 0x1E, 0xC2}, "Apple"},        {{0x00, 0x1F, 0x5B}, "Apple"},
    {{0x00, 0x1F, 0xF3}, "Apple"},        {{0x00, 0x21, 0xE9}, "Apple"},
    {{0x00, 0x22, 0x41}, "Apple"},        {{0x00, 0x23, 0x12}, "Apple"},
    {{0x00, 0x23, 0x32}, "Apple"},        {{0x00, 0x23, 0x6C}, "Apple"},
    {{0x00, 0x23, 0xDF}, "Apple"},        {{0x00, 0x24, 0x36}, "Apple"},
    {{0x00, 0x25, 0x00}, "Apple"},        {{0x00, 0x25, 0x4B}, "Apple"},
    {{0x00, 0x25, 0xBC}, "Apple"},        {{0x00, 0x26, 0x08}, "Apple"},
    {{0x00, 0x26, 0x4A}, "Apple"},        {{0x00, 0x26, 0xB0}, "Apple"},
    {{0x00, 0x26, 0xBB}, "Apple"},

    {{0x00, 0x12, 0x47}, "Samsung"},      {{0x00, 0x15, 0x99}, "Samsung"},
    {{0x00, 0x16, 0x6B}, "Samsung"},

    {{0x00, 0x13, 0xE8}, "Intel"},        {{0x00, 0x1B, 0x21}, "Intel"},
#endif
};
#define COMMON_VENDORS_COUNT (sizeof(COMMON_VENDORS) / sizeof(COMMON_VENDORS[0]))

const char *mac_vendor_get_name(const uint8_t *mac) {
  if (mac == NULL) {
    return "";
  }

  // Locally Administered Bit set: MAC is randomized
  if (mac[0] & LOCALLY_ADMINISTERED_BIT) {
    return "Randomized";
  }

  for (size_t i = 0; i < COMMON_VENDORS_COUNT; i++) {
    if (memcmp(mac, COMMON_VENDORS[i].oui, 3) == 0) {
#ifdef MAC_VENDOR_ESPRESSIF_ONLY
      return "Espressif";
#else
      return COMMON_VENDORS[i].name;
#endif
    }
  }
  return "";
}
