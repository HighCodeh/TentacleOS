// Copyright (c) 2025 HIGH CODE LLC
//
// Licensed under the Apache License, Version 2.0 (the "License");
// you may not use this file except in compliance with the License.
// You may obtain a copy of the License at
//
//     http://www.apache.org/licenses/LICENSE-2.0
//
// Unless required by applicable law or agreed to in writing, software
// distributed under the License is distributed on an "AS IS" BASIS,
// WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
// See the License for the specific language governing permissions and
// limitations under the License.

#include "mac_vendor.h"
#include <string.h>

// Simple lookup table for common OUIs
// This is not exhaustive, just popular brands.
typedef struct {
    uint8_t oui[3];
    const char *name;
} mac_oui_t;

static const mac_oui_t common_vendors[] = {
    {{0x00, 0x1A, 0x11}, "Google"},
    {{0x3C, 0x5A, 0xB4}, "Google"},
    {{0x54, 0x60, 0x09}, "Google"},
    
    {{0x00, 0x17, 0x88}, "Philips"}, // Hue
    
    {{0x00, 0x1D, 0xA5}, "Cisco"},
    {{0x00, 0x24, 0x14}, "Cisco"},
    
    {{0x00, 0x0C, 0x29}, "VMware"},
    {{0x00, 0x50, 0x56}, "VMware"},

    {{0x00, 0x1A, 0x2B}, "Ayecom"},
    
    {{0x00, 0x1E, 0x52}, "Atheros"},

    {{0xDC, 0xA6, 0x32}, "Raspberry Pi"},
    {{0xB8, 0x27, 0xEB}, "Raspberry Pi"},
    {{0xE4, 0x5F, 0x01}, "Raspberry Pi"},

    {{0x18, 0xFE, 0x34}, "Espressif"},
    {{0x24, 0x0A, 0xC4}, "Espressif"},
    {{0x24, 0x6F, 0x28}, "Espressif"},
    {{0x24, 0x62, 0xAB}, "Espressif"},
    {{0x30, 0xAE, 0xA4}, "Espressif"},
    {{0x3C, 0x71, 0xBF}, "Espressif"},
    {{0x48, 0x3F, 0xDA}, "Espressif"},
    {{0x48, 0x55, 0x19}, "Espressif"},
    {{0x54, 0x43, 0xB2}, "Espressif"},
    {{0x5C, 0xCF, 0x7F}, "Espressif"},
    {{0x60, 0x01, 0x94}, "Espressif"},
    {{0x60, 0x55, 0xF9}, "Espressif"},
    {{0x68, 0xC6, 0x3A}, "Espressif"},
    {{0x70, 0x03, 0x9F}, "Espressif"},
    {{0x7C, 0x9E, 0xBD}, "Espressif"},
    {{0x7C, 0xDF, 0xA1}, "Espressif"},
    {{0x80, 0x7D, 0x3A}, "Espressif"},
    {{0x84, 0x0D, 0x8E}, "Espressif"},
    {{0x84, 0xCC, 0xA8}, "Espressif"},
    {{0x8C, 0xAA, 0xB5}, "Espressif"},
    {{0x90, 0x97, 0xD5}, "Espressif"},
    {{0x94, 0xB9, 0x7E}, "Espressif"},
    {{0xA0, 0x20, 0xA6}, "Espressif"},
    {{0xA0, 0xB7, 0x65}, "Espressif"},
    {{0xA4, 0x7B, 0x9D}, "Espressif"},
    {{0xA4, 0xCF, 0x12}, "Espressif"},
    {{0xAC, 0x67, 0xB2}, "Espressif"},
    {{0xAC, 0xD0, 0x74}, "Espressif"},
    {{0xB0, 0xA7, 0x32}, "Espressif"},
    {{0xB4, 0xE6, 0x2D}, "Espressif"},
    {{0xB8, 0xF0, 0x09}, "Espressif"},
    {{0xBC, 0xDD, 0xC2}, "Espressif"},
    {{0xC4, 0x4F, 0x33}, "Espressif"},
    {{0xC4, 0xDD, 0x57}, "Espressif"},
    {{0xC8, 0xF0, 0x9E}, "Espressif"},
    {{0xCC, 0x50, 0xE3}, "Espressif"},
    {{0xD4, 0xD4, 0xDA}, "Espressif"},
    {{0xD4, 0xF9, 0x8D}, "Espressif"},
    {{0xD8, 0xA0, 0x1D}, "Espressif"},
    {{0xDC, 0x4F, 0x22}, "Espressif"},
    {{0xE0, 0x5A, 0x1B}, "Espressif"},
    {{0xE8, 0x68, 0xE7}, "Espressif"},
    {{0xE8, 0x9F, 0x6D}, "Espressif"},
    {{0xE8, 0xDB, 0x84}, "Espressif"},
    {{0xEC, 0x94, 0xCB}, "Espressif"},
    {{0xEC, 0xDA, 0x3B}, "Espressif"},
    {{0xF0, 0x08, 0xD1}, "Espressif"},
    {{0xF4, 0x12, 0xFA}, "Espressif"},

    {{0x00, 0x17, 0xF2}, "Apple"},
    {{0x00, 0x19, 0xE3}, "Apple"},
    {{0x00, 0x1B, 0x63}, "Apple"},
    {{0x00, 0x1C, 0xB3}, "Apple"},
    {{0x00, 0x1D, 0x4F}, "Apple"},
    {{0x00, 0x1E, 0x52}, "Apple"},
    {{0x00, 0x1E, 0xC2}, "Apple"},
    {{0x00, 0x1F, 0x5B}, "Apple"},
    {{0x00, 0x1F, 0xF3}, "Apple"},
    {{0x00, 0x21, 0xE9}, "Apple"},
    {{0x00, 0x22, 0x41}, "Apple"},
    {{0x00, 0x23, 0x12}, "Apple"},
    {{0x00, 0x23, 0x32}, "Apple"},
    {{0x00, 0x23, 0x6C}, "Apple"},
    {{0x00, 0x23, 0xDF}, "Apple"},
    {{0x00, 0x24, 0x36}, "Apple"},
    {{0x00, 0x25, 0x00}, "Apple"},
    {{0x00, 0x25, 0x4B}, "Apple"},
    {{0x00, 0x25, 0xBC}, "Apple"},
    {{0x00, 0x26, 0x08}, "Apple"},
    {{0x00, 0x26, 0x4A}, "Apple"},
    {{0x00, 0x26, 0xB0}, "Apple"},
    {{0x00, 0x26, 0xBB}, "Apple"},

    // Add more common ones (Samsung, Intel, etc.) as needed
    {{0x00, 0x12, 0x47}, "Samsung"},
    {{0x00, 0x15, 0x99}, "Samsung"},
    {{0x00, 0x16, 0x6B}, "Samsung"},
    
    {{0x00, 0x13, 0xE8}, "Intel"},
    {{0x00, 0x1B, 0x21}, "Intel"},
};

#define VENDOR_COUNT (sizeof(common_vendors) / sizeof(mac_oui_t))

const char* get_vendor_name(const uint8_t *mac) {
    if (mac == NULL) return "";
    
    // Check for randomized MAC (Locally Administered Bit)
    // 2nd hex digit is 2, 6, A, or E (e.g., x2:xx:xx...)
    if (mac[0] & 0x02) {
        return "Randomized";
    }

    for (int i = 0; i < VENDOR_COUNT; i++) {
        if (memcmp(mac, common_vendors[i].oui, 3) == 0) {
            return common_vendors[i].name;
        }
    }
    return "";
}
